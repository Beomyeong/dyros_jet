Commit message: Backup 1231

File: src/dyros_jet/dyros_jet_description/robots/dyros_jet_robot_virtual.urdf (robot description, URDF)
Before this commit: robot dyros_jet_robot, 30 links, 29 joints
Joints:
- joint WaistPitch: axis 0 0 1 -> 0 0 -1
